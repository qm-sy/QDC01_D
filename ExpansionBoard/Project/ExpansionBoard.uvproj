# Keil uVision project ExpansionBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: ExpansionBoard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Project
  group Source Group 1
    ./: STARTUP.A51 main.c
